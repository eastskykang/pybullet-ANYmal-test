Commit message: Ball bouncing test added

File: res/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=40 40 10; visual box size=40 40 0.1
